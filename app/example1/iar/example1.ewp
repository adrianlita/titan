# IAR project example1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L452RE ST STM32L452RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.PreInclude: ..\titan_config.h
  ICCARM.CCIncludePath2: ..\..\..\titan; ..\..\..\titan\kernel; ..\..\..\titan\kernel_objects; ..\..\..\bsp\cmsis; ..\..\..\bsp\stm32l4; ..\..\..\bsp\stm32l4\hal; ..\..\..\drivers; ..\..\..\libs
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: example1.hex
  ILINK.IlinkOutputFile: example1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\titan; ..\..\..\titan\kernel; ..\..\..\titan\kernel_objects; ..\..\..\arch\stm32l4\cmsis; ..\..\..\arch\stm32l4; ..\..\..\arch\stm32l4\hal
  ICCARM.CCOptLevel: 3
  group app
    ../: bsp.h main.c titan_config.h titan_setup.c
  group bsp/arch
    ./: startup_stm32l452xx.s
    ../../../bsp/stm32l4/: stm32l452xx.h stm32l4xx.h system_stm32l4xx.c system_stm32l4xx.h
  group bsp/cmsis
    ../../../bsp/cmsis/: core_cm4.h
  group bsp/hal
    ../../../bsp/stm32l4/hal/: stm32l4xx_ll_adc.c stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_crc.c stm32l4xx_ll_crc.h stm32l4xx_ll_dac.c stm32l4xx_ll_dac.h stm32l4xx_ll_exti.c stm32l4xx_ll_exti.h stm32l4xx_ll_gpio.c stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.c stm32l4xx_ll_i2c.h stm32l4xx_ll_lptim.c stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.c stm32l4xx_ll_lpuart.h stm32l4xx_ll_pwr.c stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.c stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.c stm32l4xx_ll_rng.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.c stm32l4xx_ll_tim.h stm32l4xx_ll_usart.c stm32l4xx_ll_usart.h stm32l4xx_ll_utils.c stm32l4xx_ll_utils.h
  group bsp/periph
    ../../../bsp/stm32l4/periph/: cpu.c crc32h_rng.c gpio.c gpio_pins.h i2c.c spi.c timer.c uart.c
  group drivers/nina_b312
    ../../../drivers/nina_b312/: nina_b312.c nina_b312.h
  group titan
    ../../../titan/: assert.c assert.h error.h titan.h titan_defs.h titan_load.c titan_load.h
  group titan/bluetooth
    ../../../titan/bluetooth/: bluetooth.c bluetooth.h bluetooth_sync_buffer.c bluetooth_sync_buffer.h gatt.c gatt.h
  group titan/crypto
    ../../../titan/crypto/: aes.c aes.h base64.c base64.h md5.c md5.h sha1.c sha1.h sha256.c sha256.h
  group titan/kernel
    ../../../titan/kernel/: kernel.h kernel_atomic.c kernel_atomic.h kernel_defines.h kernel_init.c kernel_isr.c kernel_objects.c kernel_scheduler.c kernel_supervisor.h kernel_utils.c kernel_utils.h
  group titan/kernel_objects
    ../../../titan/kernel_objects/: bsemaphore.c bsemaphore.h mqueue.c mqueue.h mutex.c mutex.h notification.c notification.h pqueue.c pqueue.h semaphore.c semaphore.h task.c task.h
  group titan/net
    ../../../titan/net/: netif_common.c netif_common.h
  group titan/periph
    ../../../titan/periph/: cpu.h crc32h.h gpio.h i2c.h rng.h spi.h timer.h uart.h
  group titan/utils
    ../../../titan/utils/: crc32.c crc32.h rand.c rand.h
  group titan/utils/explorer
    ../../../titan/utils/explorer/: explorer.c explorer.h
